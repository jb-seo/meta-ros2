# Generated by superflore -- DO NOT EDIT
#
# Copyright 2019 Open Source Robotics Foundation
# Distributed under the terms of the BSD license

DESCRIPTION = "Examples of minimal service servers using rclpy."
AUTHOR = "Mikael Arguedas <mikael@osrfoundation.org>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=12c26a18c7f493fdc7e8a93b16b7c04f"

ROS_BUILD_DEPENDS = "example-interfaces rclpy std-msgs"
DEPENDS = "${ROS_BUILD_DEPENDS}"

ROS_BUILDTOOL_DEPENDS = ""
DEPENDS += "${ROS_BUILDTOOL_DEPENDS}"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = "ament-copyright-native ament-flake8-native ament-pep257-native python3-pytest-native"

SRC_URI = "https://github.com/ros2-gbp/examples-release/archive/release/bouncy/examples_rclpy_minimal_service/0.5.1-0.tar.gz;downloadfilename=${ROS_SP}.tar.gz"
SRC_URI[md5sum] = "78c3cfd5ae532f4ec0c31b3fb716dd7a"
SRC_URI[sha256sum] = "66fa86d09261256292fe1e0322919f3e55e3c99589685042c76a2890743b901a"
S = "${WORKDIR}/examples-release-release-bouncy-examples_rclpy_minimal_service-0.5.1-0"

ROS_BUILD_TYPE = "ament_python"
ROS_RECIPES_TREE = "recipes-ros2"

# Allow the above settings to be overridden.
include ${ROS_LAYERDIR}/recipes-ros/examples-rclpy-minimal-service/examples-rclpy-minimal-service-common.inc
include ${ROS_LAYERDIR}/recipes-ros2/examples-rclpy-minimal-service/examples-rclpy-minimal-service-common.inc
include ${ROS_LAYERDIR}/${ROS_RECIPES_TREE}/examples-rclpy-minimal-service/examples-rclpy-minimal-service-common-${PV}.inc
include ${ROS_LAYERDIR}/${ROS_RECIPES_TREE}/examples-rclpy-minimal-service/${BPN}.inc
include ${ROS_LAYERDIR}/${ROS_RECIPES_TREE}/examples-rclpy-minimal-service/${BPN}-${PV}.inc

inherit ros_bouncy
inherit ros_${ROS_BUILD_TYPE}

